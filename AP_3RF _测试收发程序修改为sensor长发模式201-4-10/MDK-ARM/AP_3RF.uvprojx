# Keil uVision project AP_3RF.uvprojx, settings and files
target AP_3RF (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F429IITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: AP_3RF +hex
  AfterMake: C:/keil_v5/ARM/ARMCC/bin/fromelf.exe  --bin -o AP_3RF.bin ./AP_3RF/AP_3RF.axf
  c flags: OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\user;..\sx1278
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group 3RF
    ../user/: rf.c rf_hal.c ap_s.c
  group SX_1278
    ../sx1278/: sx1276.c sx1276-LoRa.c sx1276-LoRaMisc.c sx1276-Fsk.c sx1276-FskMisc.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_spi.c stm32f4xx_hal_pwr.c stm32f4xx_hal_crc.c stm32f4xx_hal_flash.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma.c stm32f4xx_hal_rcc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_uart.c stm32f4xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Application/User
    ../Src/: main.c stm32f4xx_it.c stm32f4xx_hal_timebase_TIM.c stm32f4xx_hal_msp.c
  group Uart_debug
    ../user/: debug_uart.c
  group user
    ../user/: flash.c
software components: CMSIS:CORE 4.1.0
